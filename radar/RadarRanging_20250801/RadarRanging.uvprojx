# Keil uVision project RadarRanging.uvprojx, settings and files
target RadarMCU (6230000::V6.23::ARMCLANG)
  device: STM32F427ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RadarRanging +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F427xx,USE_USB_FS
  c include: .\Drivers\Cmsis\Inc;.\Drivers\STM32F4xx_HAL_Driver\Inc;.\Drivers\System\Inc;.\User\Inc;.\Middlewares\MALLOC;.\Middlewares\USB\STM32_USB_Device_Library\Class\CDC\Inc;.\Middlewares\USB\STM32_USB_Device_Library\Core\Inc;.\Middlewares\USB\USB_APP;.\Middlewares\USB\STM32_USB_Device_Library\Class\HID\Inc;.\User\Inc;.\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2;.\Middlewares\Third_Party\FreeRTOS\Source\include;.\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/Src/: main.c stm32f4xx_it.c com_process.c data_process.c
  group Drivers/System
    ./Drivers/System/Src/: delay.c sys.c usart.c sram.c fpga.c flash.c spi.c stmflash.c tim.c
  group Drivers/HAL_Driver
    ./Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_sram.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_spi.c
  group Startup
    ./Startup/: startup_stm32f427xx.s system_stm32f4xx.c
  group Middleware/Malloc
    ./Middlewares/MALLOC/: malloc.c
  group Middleware/USB
    ./Middlewares/USB/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ./Middlewares/USB/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ./Middlewares/USB/USB_APP/: usbd_cdc_interface.c usbd_conf.c usbd_desc.c
    ./Middlewares/USB/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2, CMSIS:NN Lib 7.0.0
